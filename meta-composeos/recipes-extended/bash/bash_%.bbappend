# bbappend to reduce priority of bash to avoid make it the default system /bin/sh
ALTERNATIVE_PRIORITY = "1"
